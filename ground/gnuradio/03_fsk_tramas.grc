options:
  parameters:
    author: Alejandro Berna Mogica
    description: 'Tramas completas: generador, FSK, ruido, demodulador, sincronismo, RS y CRC'
    generate_options: qt_gui
    id: fsk_tramas
    output_language: python
    title: 03 - Tramas de telemetria (ASM + RS + CRC)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
    comment: Muestras/s
  states: {}
- name: baud
  id: variable
  parameters:
    value: '9600'
    comment: bit/s
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/baud)
    comment: Muestras por bit
  states: {}
- name: desviacion
  id: variable
  parameters:
    value: '4800'
    comment: Desviacion FSK (Hz)
  states: {}
- name: taps_lpf
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, 12000, 4000, window.WIN_HAMMING, 6.76)
    comment: Filtro paso bajo +-12 kHz
  states: {}
- name: retardo
  id: variable
  parameters:
    value: (len(taps_lpf)-1)//2
    comment: Retardo del filtro (muestras)
  states: {}
- name: asm_bits
  id: variable
  parameters:
    value: '"00011010110011111111110000011101"'
    comment: 1A CF FC 1D en binario
  states: {}
- name: ruido
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Amplitud de ruido
    start: '0'
    stop: '1.5'
    step: '0.01'
    value: '0.5'
  states: {}
- name: ebn0_db
  id: variable_qtgui_label
  parameters:
    label: Eb/N0 (dB)
    type: real
    value: 10*math.log10(samp_rate/baud/max(ruido,1e-3)**2)
    gui_hint: 1,0,1,1
  states: {}
- name: imports
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio.filter import firdes
      from gnuradio.fft import window
  states: {}
- name: generador
  id: epy_block
  parameters:
    _source_code: |
      """
      Generador de tramas: emite, bit a bit (valores 0/1), tramas reales construidas
      con ground/scripts/trama.py, cada una precedida de 4 bytes de preámbulo 0xAA.
      Los datos simulan un vuelo: el contador sube y la altitud y la presión cambian.
      """
      import math
      import os
      import sys

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, ruta_scripts='../scripts'):
              gr.sync_block.__init__(self, name='Generador de tramas', in_sig=None, out_sig=[np.uint8])
              self.ruta_scripts = ruta_scripts
              self.trama = None
              self.contador = 0
              self.bits = np.zeros(0, dtype=np.uint8)

          def start(self):
              try:
                  base = os.path.dirname(os.path.abspath(__file__))
              except NameError:
                  base = os.getcwd()
              sys.path.insert(0, os.path.normpath(os.path.join(base, self.ruta_scripts)))
              import trama
              self.trama = trama
              return True

          def nueva_trama(self):
              n = self.contador
              t = self.trama.Telemetria(
                  contador=n, tiempo_gps=453_215 + n, latitud=38.1795 + n * 1e-5,
                  longitud=-0.9725, altitud_m=12.5 + 5 * n % 3000, presion_pa=101_325 - 6 * n % 30000,
                  temperatura_c=23.41, humedad=55.2, acel_mg=(12, -8, 1002),
                  giro_dps=(0.5, -1.2, round(10 * math.sin(n / 10), 1)),
                  bateria_mv=5000, satelites=9, fix=3)
              self.contador = (n + 1) & 0xFFFF
              datos = bytes([0xAA] * 4) + self.trama.construir_trama(t)
              return np.unpackbits(np.frombuffer(datos, dtype=np.uint8))

          def work(self, input_items, output_items):
              out = output_items[0]
              while len(self.bits) < len(out):
                  self.bits = np.concatenate([self.bits, self.nueva_trama()])
              out[:] = self.bits[:len(out)]
              self.bits = self.bits[len(out):]
              return len(out)
    ruta_scripts: '''../scripts'''
    comment: Tramas reales de trama.py
  states: {}
- name: a_float
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: por_dos
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: menos_uno
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
    comment: 0/1 -> -1/+1
  states: {}
- name: repetir
  id: blocks_repeat
  parameters:
    interp: sps
    type: float
  states: {}
- name: modulador_fsk
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*desviacion/samp_rate
  states: {}
- name: fuente_ruido
  id: analog_noise_source_x
  parameters:
    amp: ruido
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
    comment: 'Canal: ruido blanco gaussiano'
  states: {}
- name: suma
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: espectro
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,0,1,2
    name: '"Espectro"'
    type: complex
    ymin: '-100'
  states: {}
- name: filtro_paso_bajo
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps_lpf
    type: ccf
  states: {}
- name: demodulador_fsk
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*desviacion)
  states: {}
- name: integrador
  id: blocks_moving_average_xx
  parameters:
    length: sps
    max_iter: '4000'
    scale: 1.0/sps
    type: float
    comment: Filtro adaptado
  states: {}
- name: muestreo
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: sps
    offset: (retardo+sps-1)%sps
    type: float
    comment: 1 muestra por bit
  states: {}
- name: decisor
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: buscar_asm
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: asm_bits
    threshold: '2'
    tagname: '"trama"'
    type: byte
    comment: Marca el inicio de cada trama (hasta 2 bits erroneos)
  states: {}
- name: descodificador
  id: epy_block
  parameters:
    _source_code: |
      """
      Descodificador de tramas: recibe los bits demodulados (0/1) y las marcas que pone
      'Correlate Access Code' al encontrar 1A CF FC 1D. Recorta los 78 bytes siguientes,
      corrige con Reed-Solomon, comprueba el CRC (trama.py) y muestra la telemetría.
      Salida: porcentaje de tramas perdidas en las últimas 100 (según huecos del contador).
      """
      import os
      import sys
      from collections import deque

      import numpy as np
      import pmt
      from gnuradio import gr

      BITS_TRAMA = 78 * 8   # datos + CRC + Reed-Solomon (el ASM ya se ha detectado)


      class blk(gr.sync_block):
          def __init__(self, ruta_scripts='../scripts', mostrar_cada=10):
              gr.sync_block.__init__(self, name='Descodificador de tramas', in_sig=[np.uint8], out_sig=[np.float32])
              self.ruta_scripts = ruta_scripts
              self.mostrar_cada = int(mostrar_cada)
              self.trama = None
              self.buffer = np.zeros(0, dtype=np.uint8)
              self.inicio_buffer = 0          # posición absoluta del primer bit del buffer
              self.pendientes = []            # posiciones absolutas donde empiezan tramas
              self.fin_ultima = -1
              self.ultimo_contador = None
              self.historial = deque(maxlen=100)   # 1 = trama recibida, 0 = perdida
              self.ok = self.corregidas = self.descartadas = 0
              self.perdidas_pct = 0.0

          def start(self):
              try:
                  base = os.path.dirname(os.path.abspath(__file__))
              except NameError:
                  base = os.getcwd()
              sys.path.insert(0, os.path.normpath(os.path.join(base, self.ruta_scripts)))
              import trama
              self.trama = trama
              return True

          def procesar(self, bits):
              datos = self.trama.ASM + np.packbits(bits).tobytes()
              try:
                  t, n_corr = self.trama.descodificar_trama(datos)
              except ValueError as e:
                  self.descartadas += 1
                  print(f"[RX] trama descartada: {e}")
                  return False
              self.ok += 1
              if n_corr:
                  self.corregidas += 1
              if self.ultimo_contador is not None:
                  hueco = (t.contador - self.ultimo_contador - 1) & 0xFFFF
                  if hueco < 1000:
                      self.historial.extend([0] * hueco)
              self.historial.append(1)
              self.ultimo_contador = t.contador
              self.perdidas_pct = 100.0 * (1 - sum(self.historial) / len(self.historial))
              if n_corr or t.contador % self.mostrar_cada == 0:
                  print(f"[RX] #{t.contador:5d}  lat {t.latitud:.5f}  lon {t.longitud:.5f}  alt {t.altitud_m:7.1f} m  "
                        f"P {t.presion_pa} Pa  T {t.temperatura_c:.2f} C  | RS corrigió {n_corr:2d} B  "
                        f"| OK {self.ok}  con correcciones {self.corregidas}  descartadas {self.descartadas}  "
                        f"perdidas {self.perdidas_pct:.0f} %")
              return True

          def work(self, input_items, output_items):
              entrada = input_items[0]
              n = len(entrada)
              pos0 = self.nitems_read(0)
              for tag in self.get_tags_in_window(0, 0, n):
                  if pmt.symbol_to_string(tag.key) == 'trama' and tag.offset > self.fin_ultima:
                      self.pendientes.append(tag.offset)
              self.buffer = np.concatenate([self.buffer, entrada])
              while self.pendientes:
                  ini = self.pendientes[0]
                  fin = ini + BITS_TRAMA
                  if fin > self.inicio_buffer + len(self.buffer):
                      break
                  self.pendientes.pop(0)
                  if ini <= self.fin_ultima:
                      continue
                  a = ini - self.inicio_buffer
                  if a >= 0 and self.procesar(self.buffer[a:a + BITS_TRAMA]):
                      self.fin_ultima = fin - 1
              conservar = 2 * BITS_TRAMA
              if len(self.buffer) > conservar:
                  quitar = len(self.buffer) - conservar
                  self.buffer = self.buffer[quitar:]
                  self.inicio_buffer += quitar
              output_items[0][:] = self.perdidas_pct
              return n
    ruta_scripts: '''../scripts'''
    mostrar_cada: '10'
    comment: RS + CRC + telemetria (ver consola)
  states: {}
- name: perdidas
  id: qtgui_number_sink
  parameters:
    name: '"Tramas perdidas (ultimas 100)"'
    type: float
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '0'
    max: '100'
    update_time: '0.5'
    gui_hint: 2,0,1,2
    label1: Perdidas
    unit1: '%'
  states: {}

connections:
- [generador, '0', a_float, '0']
- [a_float, '0', por_dos, '0']
- [por_dos, '0', menos_uno, '0']
- [menos_uno, '0', repetir, '0']
- [repetir, '0', modulador_fsk, '0']
- [modulador_fsk, '0', suma, '0']
- [fuente_ruido, '0', suma, '1']
- [suma, '0', throttle, '0']
- [throttle, '0', espectro, '0']
- [throttle, '0', filtro_paso_bajo, '0']
- [filtro_paso_bajo, '0', demodulador_fsk, '0']
- [demodulador_fsk, '0', integrador, '0']
- [integrador, '0', muestreo, '0']
- [muestreo, '0', decisor, '0']
- [decisor, '0', buscar_asm, '0']
- [buscar_asm, '0', descodificador, '0']
- [descodificador, '0', perdidas, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
